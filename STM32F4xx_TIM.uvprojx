# Keil uVision project STM32F4xx_TIM.uvprojx, settings and files
target Project_Name (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ExecutableFile +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\App;.\Bsp;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\DeviceSupport\startup;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32F4xx_StdPeriph_Driver\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup Code
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_adc.c
  group CMSIS
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f4xx.c
  group Bsp
    ./Bsp/: bsp.c timer.c adc.c oled.c usart.c
  group App
    ./App/: main.c global_variable.c stm32f4xx_it.c
  group Doc
    ./Doc/: ReadMe.txt
